# Keil uVision project usb_msc.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_msc +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c misc: --c99
  c include: .\include;.\fwlib\inc;.\usb\inc;.\fat_fs\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DOC
    ./doc/: coding_specification.txt Source_File_Module.c Head_File_Module.h
  group start_up
    ./: startup_stm32f40_41xxx.s
  group main
    ./main/: main.c
  group driver
    ./driver/: led.c stm32fxxx_it.c system_stm32f4xx.c usart.c dwin.c sensor.c battery.c sd_card.c stm324xg_eval.c stm324xg_eval_sdio_sd.c
  group usb
    ./usb/src/: usb_bsp.c usb_core.c usb_hcd.c usb_hcd_int.c usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c usbh_stdreq.c usbh_usr.c
  group fwlib
    ./fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_i2c.c stm32f4xx_flash.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group fatfs
    ./fat_fs/src/: fattime.c ff.c diskio.c
    ./fat_fs/src/option/: ccsbcs.c
software components: CMSIS:CORE 4.3.0
